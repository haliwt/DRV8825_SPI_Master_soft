# Keil uVision project SPI_Master_I2C_Slave.uvprojx, settings and files
target SPI_MASTER_I2C_SLAVE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FDI_PRO_500 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Inc\bsp;..\SYSTEM\delay;..\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_eth.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c stm32f1xx_assert.c
  group bsp
    ../Src/bsp/usart/: bsp_usartx.c
    ../Src/bsp/led/: bsp_led.c
    ../Src/bsp/DRV8825/: drv8825.c
    ../Src/bsp/GeneralTIM/: bsp_GeneralTIM.c
    ../Src/bsp/key/: bsp_key.c
    ../Src/bsp/StepMotor/: bsp_StepMotor.c
    ../Src/bsp/i2c/: bsp_EEPROM.c
    ../Src/bsp/hextodec/: hextodec.c
    ../Src/bsp/Lamp/: bsp_lamp.c
    ../Src/bsp/ds18b20/: bsp_ds18b20.c
    ../Src/bsp/spi/: bsp_spi.c
    ../Src/bsp/spi_comm/: spi_comm.c
    ../Src/bsp/I2C_SLAVE/: bsp_I2C.c
    ../Src/bsp/A1_FUN/: a1_fun.c
  group Readme
    ../Readme/: 01.例程功能说明.txt 02.开发环境说明.txt
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
